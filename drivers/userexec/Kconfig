## drivers/userexec/Kconfig
```kconfig
config USEREXEC
	bool "User exec"
	help
		Enable execution of a userspace process after boot
```
